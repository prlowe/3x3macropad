# Repository prlowe/3x3macropad

File README.md:

# 3x3macropad
3x3 macropad with a rotary encoder.  Uses an Arduino Pro Micro.

## KiCad design KEEBER/KEEBER.kicad_pcb

Parts:
R1, R2, R3, R4, R5, R6, R7, R8, R9, R10, R11, R12: 10K; R_0805_2012Metric
SW1, SW2, SW3, SW4, SW5, SW6, SW7, SW8, SW9: SW_DPST_x2; MXOnly-1U-Hotswap
SW10-0: RotaryEncoder_Switch; RotaryEncoder_Alps_EC11E-Switch_Vertical_H20mm
U1: ProMicro

Connections:
unnamed: SW1.1 (A), SW2.1 (A), SW3.1 (A), SW4.1 (A), SW5.1 (A), SW6.1 (A), SW7.1 (A), SW8.1 (A), SW9.1 (A), U1.4 (GND)
unnamed: R1.1, SW1.2 (B), U1.5 (SDA)
unnamed: R2.1, SW2.2 (B), U1.6 (SCL)
unnamed: R3.1, SW3.2 (B), U1.7 (D4)
unnamed: R4.1, SW4.2 (B), U1.8 (C6)
unnamed: R5.1, SW5.2 (B), U1.9 (D7)
unnamed: R6.1, SW6.2 (B), U1.10 (E6)
unnamed: R7.1, SW7.2 (B), U1.11 (B4)
unnamed: R8.1, SW8.2 (B), U1.12 (B5)
unnamed: R9.1, SW9.2 (B), U1.13 (B6)
unnamed: R11.2, SW10-0.B, U1.14 (B2)
unnamed: R10.2, SW10-0.A, U1.15 (B3)
unnamed: R12.1, SW10-0.S1, U1.16 (B1)
unnamed: R1.2, R2.2, R3.2, R4.2, R5.2, R6.2, R7.2, R8.2, R9.2, R10.1, R11.1, R12.2, U1.21 (VCC)
unnamed: SW10-0.C, SW10-0.S2, U1.23 (GND)

Board: 2 copper layers, 59.7 x 81.3 mm, 23 parts (0 on the bottom side), 15 nets.
